inherit externalsrc
EXTERNALSRC = "/home/amelie/w/src/esme-3s11-gpio-toggle"
EXTERNALSRC_BUILD = "/home/amelie/w/src/esme-3s11-gpio-toggle"

# initial_rev .: b378ee43e1f5b9fddbc0daf872ccdb6f305a05cb
