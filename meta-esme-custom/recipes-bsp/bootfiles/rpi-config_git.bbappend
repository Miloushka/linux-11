# Extension of the rpi-config recipe
# Enables the default UART console on Raspberry Pi

ENABLE_UART = "1"