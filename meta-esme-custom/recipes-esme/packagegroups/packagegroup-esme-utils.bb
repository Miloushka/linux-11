LICENSE = "CLOSED"

inherit packagegroup

RDEPENDS:${PN} = "\
    esme-gpio-toggle \
"
