IMAGE_INSTALL:append = " packagegroup-esme-utils"
